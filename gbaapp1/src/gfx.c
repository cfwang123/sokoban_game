#include "gfx.h"

/* Mode-3 offscreen buffer in EWRAM */
static u16 g_back[SCREEN_W * SCREEN_H] __attribute__((section(".ewram"), aligned(4)));

/* Tiny 5x7 font glyphs for A-Z 0-9 and symbols */
static const u8 FONT[48][7] = {
	/* 0-9 */
	{0x0E, 0x11, 0x13, 0x15, 0x19, 0x11, 0x0E},
	{0x04, 0x0C, 0x04, 0x04, 0x04, 0x04, 0x0E},
	{0x0E, 0x11, 0x01, 0x02, 0x04, 0x08, 0x1F},
	{0x1E, 0x01, 0x01, 0x0E, 0x01, 0x01, 0x1E},
	{0x02, 0x06, 0x0A, 0x12, 0x1F, 0x02, 0x02},
	{0x1F, 0x10, 0x1E, 0x01, 0x01, 0x11, 0x0E},
	{0x06, 0x08, 0x10, 0x1E, 0x11, 0x11, 0x0E},
	{0x1F, 0x01, 0x02, 0x04, 0x08, 0x08, 0x08},
	{0x0E, 0x11, 0x11, 0x0E, 0x11, 0x11, 0x0E},
	{0x0E, 0x11, 0x11, 0x0F, 0x01, 0x02, 0x0C},
	/* A-Z */
	{0x0E, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11}, /* A */
	{0x1E, 0x11, 0x11, 0x1E, 0x11, 0x11, 0x1E},
	{0x0E, 0x11, 0x10, 0x10, 0x10, 0x11, 0x0E},
	{0x1E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E},
	{0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x1F},
	{0x1F, 0x10, 0x10, 0x1E, 0x10, 0x10, 0x10},
	{0x0E, 0x11, 0x10, 0x17, 0x11, 0x11, 0x0F},
	{0x11, 0x11, 0x11, 0x1F, 0x11, 0x11, 0x11},
	{0x0E, 0x04, 0x04, 0x04, 0x04, 0x04, 0x0E},
	{0x01, 0x01, 0x01, 0x01, 0x11, 0x11, 0x0E},
	{0x11, 0x12, 0x14, 0x18, 0x14, 0x12, 0x11},
	{0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F},
	{0x11, 0x1B, 0x15, 0x15, 0x11, 0x11, 0x11},
	{0x11, 0x19, 0x15, 0x13, 0x11, 0x11, 0x11},
	{0x0E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E},
	{0x1E, 0x11, 0x11, 0x1E, 0x10, 0x10, 0x10},
	{0x0E, 0x11, 0x11, 0x11, 0x15, 0x12, 0x0D},
	{0x1E, 0x11, 0x11, 0x1E, 0x14, 0x12, 0x11},
	{0x0F, 0x10, 0x10, 0x0E, 0x01, 0x01, 0x1E},
	{0x1F, 0x04, 0x04, 0x04, 0x04, 0x04, 0x04},
	{0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x0E},
	{0x11, 0x11, 0x11, 0x11, 0x11, 0x0A, 0x04},
	{0x11, 0x11, 0x11, 0x15, 0x15, 0x1B, 0x11},
	{0x11, 0x11, 0x0A, 0x04, 0x0A, 0x11, 0x11},
	{0x11, 0x11, 0x0A, 0x04, 0x04, 0x04, 0x04},
	{0x1F, 0x01, 0x02, 0x04, 0x08, 0x10, 0x1F}, /* Z */
	/* symbols: space : / - > ! */
	{0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00},
	{0x00, 0x04, 0x04, 0x00, 0x04, 0x04, 0x00},
	{0x01, 0x02, 0x04, 0x08, 0x10, 0x00, 0x00},
	{0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00},
	{0x08, 0x0C, 0x0E, 0x0C, 0x08, 0x00, 0x00},
	{0x04, 0x04, 0x04, 0x04, 0x00, 0x04, 0x00},
};

static int font_index(char c)
{
	if (c >= '0' && c <= '9')
		return c - '0';
	if (c >= 'A' && c <= 'Z')
		return 10 + (c - 'A');
	if (c >= 'a' && c <= 'z')
		return 10 + (c - 'a');
	if (c == ' ')
		return 36;
	if (c == ':')
		return 37;
	if (c == '/')
		return 38;
	if (c == '-')
		return 39;
	if (c == '>')
		return 40;
	if (c == '!')
		return 41;
	return 36;
}

void gfx_init(void)
{
	REG_DISPCNT = MODE_3 | BG2_ENABLE;
	gfx_clear(RGB15(0, 0, 0));
	gfx_flip();
}

u16 *gfx_back(void) { return g_back; }

void gfx_clear(u16 c)
{
	u32 fill = ((u32)c << 16) | c;
	dma_fill32(g_back, fill, (SCREEN_W * SCREEN_H) / 2);
}

void gfx_fill(int x, int y, int w, int h, u16 c)
{
	int j, i;
	if (w <= 0 || h <= 0)
		return;
	if (x < 0) {
		w += x;
		x = 0;
	}
	if (y < 0) {
		h += y;
		y = 0;
	}
	if (x + w > SCREEN_W)
		w = SCREEN_W - x;
	if (y + h > SCREEN_H)
		h = SCREEN_H - y;
	if (w <= 0 || h <= 0)
		return;
	for (j = 0; j < h; j++) {
		u16 *row = &g_back[(y + j) * SCREEN_W + x];
		for (i = 0; i < w; i++)
			row[i] = c;
	}
}

void gfx_blit_tile(int dx, int dy, int tid)
{
	const u16 *src;
	int y, x;
	if ((unsigned)tid >= (unsigned)GFX_TILE_COUNT)
		return;
	src = gfx_tiles[tid];
	for (y = 0; y < CELL; y++) {
		int sy = dy + y;
		if ((unsigned)sy >= SCREEN_H)
			continue;
		for (x = 0; x < CELL; x++) {
			int sx = dx + x;
			if ((unsigned)sx < SCREEN_W)
				g_back[sy * SCREEN_W + sx] = src[y * CELL + x];
		}
	}
}

void gfx_blit_tile_key(int dx, int dy, int tid, u16 key)
{
	const u16 *src;
	int y, x;
	if ((unsigned)tid >= (unsigned)GFX_TILE_COUNT)
		return;
	src = gfx_tiles[tid];
	for (y = 0; y < CELL; y++) {
		int sy = dy + y;
		if ((unsigned)sy >= SCREEN_H)
			continue;
		for (x = 0; x < CELL; x++) {
			u16 c = src[y * CELL + x];
			int sx = dx + x;
			if (c != key && (unsigned)sx < SCREEN_W)
				g_back[sy * SCREEN_W + sx] = c;
		}
	}
}

void gfx_flip(void)
{
	dma_copy32(vram(), g_back, (SCREEN_W * SCREEN_H) / 2);
}

void gfx_text(int x, int y, const char *s, u16 color)
{
	int cx = x;
	while (*s) {
		int idx = font_index(*s);
		const u8 *g = FONT[idx];
		int row, col;
		for (row = 0; row < 7; row++) {
			u8 bits = g[row];
			for (col = 0; col < 5; col++) {
				if (bits & (0x10 >> col)) {
					int px = cx + col;
					int py = y + row;
					if ((unsigned)px < SCREEN_W && (unsigned)py < SCREEN_H)
						g_back[py * SCREEN_W + px] = color;
				}
			}
		}
		cx += 6;
		s++;
	}
}

void gfx_text_shadow(int x, int y, const char *s, u16 color, u16 shadow)
{
	gfx_text(x + 1, y + 1, s, shadow);
	gfx_text(x, y, s, color);
}
